# Keil uVision project blink.uvprojx, settings and files
target blink (ARM-ADS)
  device: GD32F330K8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blink
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group source
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:GD32F3x0_StdPeripherals:ADC 2.2.0, Device:GD32F3x0_StdPeripherals:CEC 2.2.0, Device:GD32F3x0_StdPeripherals:CMP 2.2.0, Device:GD32F3x0_StdPeripherals:CRC 2.2.0, Device:GD32F3x0_StdPeripherals:CTC 2.2.0, Device:GD32F3x0_StdPeripherals:DAC 2.2.0, Device:GD32F3x0_StdPeripherals:DBG 2.2.0, Device:GD32F3x0_StdPeripherals:DMA 2.2.0, Device:GD32F3x0_StdPeripherals:EXTI 2.2.0, Device:GD32F3x0_StdPeripherals:FMC 2.2.0, Device:GD32F3x0_StdPeripherals:FWDGT 2.2.0, Device:GD32F3x0_StdPeripherals:GPIO 2.2.0, Device:GD32F3x0_StdPeripherals:I2C 2.2.0, Device:GD32F3x0_StdPeripherals:MISC 2.2.0, Device:GD32F3x0_StdPeripherals:PMU 2.2.0, Device:GD32F3x0_StdPeripherals:RCU 2.2.0, Device:GD32F3x0_StdPeripherals:RTC 2.2.0, Device:GD32F3x0_StdPeripherals:SPI_I2S 2.2.0, Device:GD32F3x0_StdPeripherals:SYSCFG 2.2.0, Device:GD32F3x0_StdPeripherals:TIMER 2.2.0, Device:GD32F3x0_StdPeripherals:TSI 2.2.0, Device:GD32F3x0_StdPeripherals:USART 2.2.0, Device:GD32F3x0_StdPeripherals:WWDGT 2.2.0, Device:GD32F3x0_libopt 2.2.0, Device:Startup 2.2.0
